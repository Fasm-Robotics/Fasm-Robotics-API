Commit message: caca

File: robotarm_corrected.urdf (robot description, URDF)
Before this commit: robot robotarm, 6 links, 5 joints
Joints:
- joint SH1: axis 0 1 0 -> 0 0 1
- joint SH2: origin xyz=0 1 0 rpy=0 0 0 -> xyz=0 0 1 rpy=0 0 0
